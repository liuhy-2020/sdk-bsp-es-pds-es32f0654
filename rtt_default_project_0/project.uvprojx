# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ES32F0654LT Eastsoft
  pack: Eastsoft.ES32_DFP.7.2350
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __RTTHREAD__, ES32F065x
  c include: applications;.;drivers;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;libraries\CMSIS\Device\EastSoft\ES32F065x\Include;libraries\CMSIS\Include;libraries\ES32F065x_ALD_StdPeriph_Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    applications/: main.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../components/drivers/pm/: pm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    libraries/ES32F065x_ALD_StdPeriph_Driver/Source/: ald_acmp.c ald_adc.c ald_bkpc.c ald_calc.c ald_can.c ald_cmu.c ald_crc.c ald_crypt.c ald_dma.c ald_flash.c ald_flash_ext.c ald_gpio.c ald_i2c.c ald_iap.c ald_pis.c ald_pmu.c ald_rmu.c ald_rtc.c ald_smartcard.c ald_spi.c ald_timer.c ald_trng.c ald_tsense.c ald_uart.c ald_usart.c ald_wdt.c utils.c
    libraries/CMSIS/Device/EastSoft/ES32F065x/Startup/keil/: startup_es32f065x.s
